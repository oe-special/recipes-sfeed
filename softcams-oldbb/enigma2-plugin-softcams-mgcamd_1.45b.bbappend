SUMMARY_${PN}_append = " (Long ECM patched)"
DESCRIPTION_${PN}_append = "\n \
- with patch for long ECM"
