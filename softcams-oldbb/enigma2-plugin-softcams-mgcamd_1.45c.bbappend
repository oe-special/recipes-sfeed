SUMMARY_${PN}_append = " (Long ECM & Sky-DE patched)"
DESCRIPTION_${PN}_append = "\n \
- with patch for long ECM\n \
- with patch for support of German Sky V13/V14/V15 cards"

