SUMMARY:${PN}:append = " (Long ECM patched)"
DESCRIPTION:${PN}:append = "\n \
- with patch for long ECM"
