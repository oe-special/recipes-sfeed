CAMNAME="gbox"

require gbox-common.inc
