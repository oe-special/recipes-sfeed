include oscam-trunk-stable.inc
include oscam-trunk.inc
include oscam-ipv6.inc

SUMMARY = "OSCam-stable ${PV}"
