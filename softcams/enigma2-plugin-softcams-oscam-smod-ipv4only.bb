require oscam-smod.inc
require oscam-ipv4.inc
