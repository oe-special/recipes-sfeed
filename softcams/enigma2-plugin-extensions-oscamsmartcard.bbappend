SRC_URI="git://github.com/oe-special/oscamsmartcard.git;protocol=https;branch=master"
