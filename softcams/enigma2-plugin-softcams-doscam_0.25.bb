CAMNAME="doscam"

require doscam-common.inc
