require ./oscam-icam.inc
require ./oscam-trunk.inc
require ./oscam-ipv6.inc
