CAMNAME="CCcam"

require cccam-common.inc
SUMMARY_${PN}_append = " (Sky-DE patched)"
DESCRIPTION_${PN}_append = " \
- with patch for support of German Sky V13/V14/V15 cards\n \
"
