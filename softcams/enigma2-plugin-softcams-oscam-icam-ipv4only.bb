require ./oscam-icam.inc
require ./oscam-trunk.inc
require ./oscam-ipv4.inc
