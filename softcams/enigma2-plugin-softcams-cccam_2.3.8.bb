CAMNAME="CCcam"

require cccam-common.inc
