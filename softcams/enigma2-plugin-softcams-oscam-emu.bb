require ./oscam-emu.inc
require ./oscam-ipv6.inc
