CAMNAME="wicardd"

require wicardd-common.inc

SUMMARY_${PN}_append = " (beelive)"
