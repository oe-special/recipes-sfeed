CAMNAME="scam"

require scam-common.inc
