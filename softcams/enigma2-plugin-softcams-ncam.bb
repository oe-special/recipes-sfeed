require ncam.inc
require oscam-ipv6.inc
